LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS_${PN} = "\
    rpi-config \
    mc \
"
